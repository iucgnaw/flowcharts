options:
  parameters:
    generate_options: qt_gui
    id: ex8_01
    output_language: python
    title: Figure 8.8 Acquisition sequence
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '9'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '8'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,int(sps*nfilts), 1.0, 0.6, int(5*sps*nfilts))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 156.8e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/symb_rate
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '72000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/output.s
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/file.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 180502_19h12_after_decim.bin
    file: MeteorM2N_180501_17h52_after_resampler.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: digital.constellation_calcdist(([-1-1j, -1+1j, 1+1j, 1-1j]), ([0, 1, 3, 2]), 4, 1).base()
    npwr: '-1'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*numpy.pi/500
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '0.707'
    loop_bw: 2*numpy.pi/2000
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '2.5'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: decimation
    gain: '1'
    samp_rate: samp_rate*decimation
    type: fir_filter_ccf
    width: samp_rate/10
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 137.9e6
    gain0: '39'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate*decimation
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}

connections:
- [analog_agc2_xx_0, '0', digital_costas_loop_cc_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', analog_agc2_xx_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', analog_rail_ff_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_agc2_xx_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_1, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
