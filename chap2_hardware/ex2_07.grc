options:
  parameters:
    generate_options: qt_gui
    id: ex2_07
    output_language: python
    title: Figure 2.11 Step by step decimation
  states: {}

blocks:
- name: Naudio
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Ndec
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Ntaps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: samp_rate=48000*Ndec*Naudio
    value: 48000*Naudio*Ndec
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: Naudio
    comment: |-
      quadrature=samp_rate/Ndec
      decimation=Naudio
      input rate shoud be WBFM bandwidth or about 200 kHz
    quad_rate: samp_rate/Ndec
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      sample rate=int(samp_rate/Ndec/Naudio)
      audio rate determined by sound card
    samp_rate: int(samp_rate/Ndec/Naudio)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      decimation=Ndec
      cutoff frequency=samp_rarte/Ndec/2
      transition width=samp_rate/Ntaps
    cutoff_freq: samp_rate/Ndec/2
    decim: Ndec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/Ntaps
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    comment: |-
      center frequency=102.4e6
      RF gain=40
    freq0: 102.4e6
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
