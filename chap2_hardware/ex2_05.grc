options:
  parameters:
    generate_options: qt_gui
    id: ex2_05
    output_language: python
    title: Figure 2.9 Spectrum of part of the FM broadcast band as monitored by SDR
  states: {}

blocks:
- name: f
  id: variable_qtgui_range
  parameters:
    start: '88'
    step: '.1'
    stop: '108'
    value: '96.9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 96000*16
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: f*1e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: center freq=f*1e6
    fc: f*1e6
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    center_freq: f*1e6
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
