options:
  parameters:
    generate_options: qt_gui
    id: ex2_02
    output_language: python
    title: Figure 2.6 Simultaneous decoding of multiple channels
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*24
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/N/2
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate/N/2
    win: window.WIN_HAMMING
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '3'
  states: {}
- name: acars_acars_0
  id: acars_acars
  parameters:
    filename: /tmp/log0
    saveall: 'False'
    threshold: threshold
  states: {}
- name: acars_acars_0_0
  id: acars_acars
  parameters:
    filename: /tmp/logp200
    saveall: 'False'
    threshold: threshold
  states: {}
- name: acars_acars_0_1
  id: acars_acars
  parameters:
    filename: /tmp/logm125
    saveall: 'False'
    threshold: threshold
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(24/N)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/N
  states: {}
- name: analog_am_demod_cf_0_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(24/N)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/N
  states: {}
- name: analog_am_demod_cf_0_1
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(24/N)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/N
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '65e-3'
    min_freq: '-65e-3'
    w: '50e-3'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:0
    samp_rate: int(samp_rate/24)
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../../3.8ng/examples/gr-acars_1.152M_2.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '200000'
    comment: 131.725-0.200=131.525 MHz secondary frequency
    decim: N
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-125000'
    comment: 131.725+0.125=131.850 new Europe channel
    decim: N
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: at 131.725 MHz primary Europe frequency
    cutoff_freq: samp_rate/N/2
    decim: N
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/N/2
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 131.725e6
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_am_demod_cf_0, '0', acars_acars_0, '0']
- [analog_am_demod_cf_0, '0', audio_sink_0, '0']
- [analog_am_demod_cf_0_0, '0', acars_acars_0_1, '0']
- [analog_am_demod_cf_0_1, '0', acars_acars_0_0, '0']
- [analog_pll_carriertracking_cc_0, '0', analog_am_demod_cf_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_am_demod_cf_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_am_demod_cf_0_0, '0']
- [low_pass_filter_0, '0', analog_am_demod_cf_0, '0']
- [low_pass_filter_0, '0', analog_pll_carriertracking_cc_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
