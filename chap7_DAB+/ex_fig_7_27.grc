options:
  parameters:
    author: Hervé Boeglen
    generate_options: qt_gui
    id: ex_fig_7_27
    output_language: python
    title: Figure 7.27 ODRmmbTools DAB Mode I reception
  states: {}

blocks:
- name: dab_params
  id: variable
  parameters:
    value: dp.dab_parameters(1,samp_rate,0)
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency
    type: int
    value: '199360000'
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2048/32
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1.0/np.sqrt(2048)]*dab_params.fft_length'
    type: complex
    vlen: dab_params.fft_length
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '1536'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"Start"'
    name: Test
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1536'
    type: complex
  states: {}
- name: dab_demux_cc_0
  id: dab_demux_cc
  parameters:
    fillval: complex(0,0)
    symbol_length: dab_params.num_carriers
    symbols_fic: dab_params.num_fic_syms
    symbols_msc: dab_params.num_msc_syms
  states: {}
- name: dab_diff_phasor_vcc_0
  id: dab_diff_phasor_vcc
  parameters:
    vlen: '1536'
  states: {}
- name: dab_fic_decode_vc_0
  id: dab_fic_decode_vc
  parameters:
    dab_mode: '1'
    samp_rate: samp_rate
  states: {state: disabled}
- name: dab_firecode_check_bb_0
  id: dab_firecode_check_bb
  parameters:
    bit_rate_n: int(88/8)
  states: {}
- name: dab_frequency_interleaver_vcc_0
  id: dab_frequency_interleaver_vcc
  parameters:
    interleaving_sequence: dab_params.frequency_deinterleaving_sequence_array
  states: {}
- name: dab_mp4_decode_bs_0
  id: dab_mp4_decode_bs
  parameters:
    bit_rate_n: int(88/8)
  states: {}
- name: dab_msc_decode_0
  id: dab_msc_decode
  parameters:
    address: '264'
    dab_mode: '1'
    debug: 'False'
    protection: '2'
    samp_rate: samp_rate
    size: '66'
    verbose: 'False'
  states: {}
- name: dab_ofdm_coarse_frequency_correction_vcvc_0
  id: dab_ofdm_coarse_frequency_correction_vcvc
  parameters:
    cyclic_prefix_length: dab_params.cp_length
    fft_length: dab_params.fft_length
    num_carriers: dab_params.num_carriers
  states: {}
- name: dab_ofdm_synchronization_cvc_0
  id: dab_ofdm_synchronization_cvc
  parameters:
    cyclic_prefix_length: dab_params.cp_length
    fft_length: dab_params.fft_length
    null_symbol_length: dab_params.ns_length
    symbols_per_frame: dab_params.symbols_per_frame
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: dab_params.fft_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio.dab.parameters as dp
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      This is a DAB+ receiver using only elementary blocks. 
      The hier blocks of gr-dab work well but are not very useful when you want to understand the decoding of a DAB+ signal.
      * Blocks from DAB OFDM Synchronization to DAB Demultiplexer = DAB OFDM Demodulator hier block.
      * Blocks from DAB: MSC Decoder to short to float blocks = DAB+ Audio Decoder hier block.
      * Init corresponds to DAB+ Mode 1: dp.dab_parameters(1,samp_rate,0).
      * 206.352 MHz is channel 9C (DAB+ channel in my area).
    note: Instructions
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: dab_params.fft_length
    type: complex
    ymax: '-40'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: 1024*256
    srate: samp_rate
    tr_level: '0'
    tr_tag: '"Start"'
    type: complex
  states: {}
- name: reed_solomon_decode_bb_0
  id: reed_solomon_decode_bb
  parameters:
    bit_rate_n: int(88/8)
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: '-3'
    dc_offset_mode0: '1'
    freq0: freq
    gain0: gain_slider
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '1'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Part1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Part2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Const
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Part1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Part2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Const
  states: {}

connections:
- [blocks_file_source_0, '0', dab_ofdm_synchronization_cvc_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_tag_debug_0, '0']
- [blocks_multiply_const_vxx_1, '0', dab_ofdm_coarse_frequency_correction_vcvc_0, '0']
- [blocks_short_to_float_0, '0', audio_sink_0, '0']
- [blocks_short_to_float_1, '0', audio_sink_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_vxx_0, '0']
- [dab_demux_cc_0, '0', blocks_null_sink_0, '0']
- [dab_demux_cc_0, '0', dab_fic_decode_vc_0, '0']
- [dab_demux_cc_0, '1', dab_msc_decode_0, '0']
- [dab_demux_cc_0, '1', virtual_sink_2, '0']
- [dab_diff_phasor_vcc_0, '0', dab_frequency_interleaver_vcc_0, '0']
- [dab_firecode_check_bb_0, '0', reed_solomon_decode_bb_0, '0']
- [dab_frequency_interleaver_vcc_0, '0', dab_demux_cc_0, '0']
- [dab_mp4_decode_bs_0, '0', blocks_short_to_float_0, '0']
- [dab_mp4_decode_bs_0, '1', blocks_short_to_float_1, '0']
- [dab_msc_decode_0, '0', virtual_sink_1, '0']
- [dab_ofdm_coarse_frequency_correction_vcvc_0, '0', virtual_sink_0, '0']
- [dab_ofdm_synchronization_cvc_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [reed_solomon_decode_bb_0, '0', dab_mp4_decode_bs_0, '0']
- [rtlsdr_source_0, '0', dab_ofdm_synchronization_cvc_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', dab_diff_phasor_vcc_0, '0']
- [virtual_source_1, '0', dab_firecode_check_bb_0, '0']
- [virtual_source_2, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
