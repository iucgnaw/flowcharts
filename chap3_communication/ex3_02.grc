options:
  parameters:
    generate_options: qt_gui
    id: ex3_02
    output_language: python
    title: Figure 3.4 Decoding 4 POCSAG channels simultaneously
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 22050*64
    value: 22050*64
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '15000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: samp_rate/8
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: samp_rate/8
  states: {}
- name: analog_wfm_rcv_0_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: samp_rate/8
  states: {}
- name: analog_wfm_rcv_0_0_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: samp_rate/8
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '8000'
    interp: '1'
    low_cutoff_freq: '50'
    samp_rate: samp_rate/64
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '8000'
    interp: '1'
    low_cutoff_freq: '50'
    samp_rate: samp_rate/64
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '8000'
    interp: '1'
    low_cutoff_freq: '50'
    samp_rate: samp_rate/64
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '8000'
    interp: '1'
    low_cutoff_freq: '50'
    samp_rate: samp_rate/64
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      multimon-ng assumes 22050 Hz, 
      16-bit signed stream

      multimon-ng -t raw -c -a SCOPE -a POCSAG512 \
      -a POCSAG1200 -a POCSAG2400 /tmp/1
    file: /tmp/1
    type: short
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/2
    type: short
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/3
    type: short
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/4
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 300e3
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: 300e3
  states: {}
- name: blocks_float_to_short_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 300e3
  states: {}
- name: blocks_float_to_short_0_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 300e3
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-25000'
    decim: '8'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '125000'
    decim: '8'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '100000'
    decim: '8'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    comment: |-
      466.025
      466.050
      466.075
      466.175
      466.20625
      466.23125
    freq0: 466.05e6
    gain0: '42'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', band_pass_filter_0, '0']
- [analog_wfm_rcv_0_0, '0', band_pass_filter_0_0, '0']
- [analog_wfm_rcv_0_0_0, '0', band_pass_filter_0_0_0, '0']
- [analog_wfm_rcv_0_0_0_0, '0', band_pass_filter_0_0_0_0, '0']
- [band_pass_filter_0, '0', blocks_float_to_short_0, '0']
- [band_pass_filter_0_0, '0', blocks_float_to_short_0_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_float_to_short_0_0_0, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_float_to_short_0_0_0_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_float_to_short_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_float_to_short_0_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_wfm_rcv_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_wfm_rcv_0_0_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
