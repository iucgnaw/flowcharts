options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ex1_06
    output_language: python
  states: {}

blocks:
- name: df
  id: variable_qtgui_range
  parameters:
    comment: |-
      -310 Hz for B210
      000 Hz for X310
    start: '-10000'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: f_rx
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '200'
    value: '143.05'
  states: {}
- name: flo_rx
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '56.95'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*32
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '800'
    gain: '1.0'
    samp_rate: samp_rate/100
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: df
    decim: '20'
    samp_rate: samp_rate/100
    taps: taps
    type: ccc
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/200
    decim: '5'
    gain: '1'
    samp_rate: samp_rate/20
    type: fir_filter_ccf
    width: samp_rate/1000
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/40
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/40
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/20/5/20
    fc: '0'
    fftsize: 1024*4
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    bw0: 0e6
    center_freq0: flo_rx*1e6
    clock_rate: '0.0'
    clock_source0: external
    dev_addr: addr0=192.168.12.2
    dev_args: '""'
    gain0: '6'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sd_spec0: A:AB B:AB
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [low_pass_filter_0_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [low_pass_filter_0_2_0, '0', low_pass_filter_0_0_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
