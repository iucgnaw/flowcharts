options:
  parameters:
    generate_options: qt_gui
    id: ex_fig_6_4
    output_language: python
    title: Figure 6.4 DAB+ start of frame generation
  states: {}

blocks:
- name: dab_params
  id: variable
  parameters:
    value: dp.dab_parameters(1,samp_rate,0)
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency
    type: int
    value: '199360000'
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"Start"'
    name: Test
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: dab_ofdm_synchronization_cvc_0
  id: dab_ofdm_synchronization_cvc
  parameters:
    cyclic_prefix_length: dab_params.cp_length
    fft_length: dab_params.fft_length
    null_symbol_length: dab_params.ns_length
    symbols_per_frame: dab_params.symbols_per_frame
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: dab_params.fft_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio.dab.parameters as dp
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Signal 1 - I
    label2: Signal 1 - Q
    size: '2048'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Start"'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: '-3'
    dc_offset_mode0: '1'
    freq0: freq
    gain0: gain_slider
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '1'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [dab_ofdm_synchronization_cvc_0, '0', blocks_tag_debug_0, '0']
- [dab_ofdm_synchronization_cvc_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [rtlsdr_source_0, '0', dab_ofdm_synchronization_cvc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
