options:
  parameters:
    generate_options: qt_gui
    id: ex_fig_6_8
    output_language: python
    realtime_scheduling: '1'
    title: Figure 6.8 NRF24L01+ receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '5e-4'
    gate: 'False'
    ramp: '0'
    threshold: '-40'
    type: complex
  states: {}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: digital_gfsk_demod_1
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(samp_rate/symbol_rate)
    sensitivity: 1.5707/(samp_rate/symbol_rate)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2520000000'
    gain1: '''manual'''
    manual_gain1: '70'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.2e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 250e3
    win: window.WIN_HAMMING
  states: {}
- name: nordic_nordic_rx_0
  id: nordic_nordic_rx
  parameters:
    address_length: '5'
    channel: '120'
    crc_length: '2'
    data_rate: '2'
  states: {}
- name: nordic_nordictap_printer_0
  id: nordic_nordictap_printer
  parameters: {}
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: 56e6
    dc_offset_mode0: '2'
    freq0: 2.52e9
    gain0: '70'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: int(samp_rate)
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '256'
    srate: samp_rate/(samp_rate/symbol_rate)
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: decode
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: decode
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', low_pass_filter_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_2, '0', qtgui_time_sink_x_2_0_0, '0']
- [digital_gfsk_demod_1, '0', blocks_char_to_float_2, '0']
- [digital_gfsk_demod_1, '0', nordic_nordic_rx_0, '0']
- [iio_pluto_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [nordic_nordic_rx_0, nordictap_out, nordic_nordictap_printer_0, nordictap_in]
- [osmosdr_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [virtual_source_0, '0', digital_gfsk_demod_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
