options:
  parameters:
    generate_options: qt_gui
    id: ex_fig_6_1
    output_language: python
    title: Figure 6.1 Changing the frequency of the Signal Source block in real time
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Activate "Show Msg Ports" = Yes
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """Btn_Click_To_Cmd"""

          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Btn_Click_To_Cmd",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('btn_in'))
              self.message_port_register_out(pmt.intern('cmd_out'))
              self.set_msg_handler(pmt.intern('btn_in'), self.handle_msg)
              self.counter = 1
              self.fvalue = 1000.0
              self.freq = 0.0

          def handle_msg(self, msg):
              key = pmt.car(msg)
              value = pmt.cdr(msg)
              
              if key == pmt.intern("pressed"):
                  self.counter = self.counter + 1
                  if self.counter == 6:
                      self.counter = 1
                  self.freq = self.counter * self.fvalue
             
              self.message_port_pub(pmt.intern('cmd_out'), pmt.cons(pmt.intern("freq"),pmt.from_float(self.freq)))
  states: {}
- name: freq_chg
  id: variable_qtgui_msg_push_button
  parameters:
    comment: Click on button to change signal freq.
    msgName: pressed
    type: bool
    value: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Signal 1 - I
    label2: Signal 1 - Q
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, cmd_out, zeromq_pub_msg_sink_0, in]
- [freq_chg, pressed, epy_block_0, btn_in]
- [zeromq_sub_msg_source_0, out, analog_sig_source_x_0, cmd]
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
