options:
  parameters:
    generate_options: qt_gui
    id: ex_fig_6_12
    output_language: python
    title: Figure 6.12 QPSK packet reception added blocks
  states: {}

blocks:
- name: Ex_BW
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '0.2'
    step: '0.05'
    stop: '0.6'
    value: '0.4'
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '0.1e-3'
    step: '0.5e-3'
    stop: '500e-3'
    value: 2*numpy.pi/150
  states: {}
- name: fft_length
  id: variable
  parameters:
    value: '512'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 850e6
  states: {}
- name: my_const
  id: variable_constellation
  parameters:
    const_points: digital.constellation_qpsk().points()
    precision: '8'
    sym_map: '[0, 2, 3, 1]'
    type: qpsk
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: probe_fft_bin
  id: variable_function_probe
  parameters:
    block_id: fft_bin
    function_name: level
    poll_rate: '5'
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '30'
    value: '17'
  states: {}
- name: rrc_taps_2
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,sps*nfilts, 1.0, Ex_BW, 5*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*symb_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '2.6'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '0.1e-3'
    step: '0.5e-3'
    stop: '100e-3'
    value: 2*numpy.pi/2000
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: fft_length
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_length
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_length
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"burst"'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_length
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: my_const
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: burst
    threshold: '1'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,3,1,2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: 1.0/numpy.sqrt(2.0)
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps_2
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_len=1024.0, samp_rate=32000.0, previous_freq=0.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Carrier Offset Calculation',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.int32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fft_len = fft_len
              self.samp_rate = samp_rate
              self.previous_freq = previous_freq
              #self.my_log = gr.logger(self.alias())
                  
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              if (input_items[0][0] > self.fft_len/2):
                 freq = -(1-(input_items[0][0]/self.fft_len))*self.samp_rate
              else:
              	freq = (input_items[0][0]/self.fft_len)*self.samp_rate
              	
              #fr = freq[-1].astype(np.float) 
              #print('fr =', fr)
            	
              #pr_fr = self.previous_freq  
              #print('pr_fr =', pr_fr)    
              
              if (self.previous_freq == 0.0):
              	self.previous_freq = freq
              	#print(self.previous_freq)
              else:
              	#print('Calc = ', abs(self.previous_freq[-1].astype(np.float) - freq[-1].astype(np.float)))
              	#print('Freq = ', freq[-1].astype(np.float))
              	freq = self.previous_freq
              	#print('Previous_freq = ', self.previous_freq[-1].astype(np.float)) 
              	      	
              output_items[0][:] = np.round(freq).astype(int)
              return len(output_items[0])
    fft_len: fft_length
    previous_freq: '0.0'
    samp_rate: samp_rate/20
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """Packet Print ASCII"""

          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Packet Print ASCII",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('PDU_in'))
              #self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)

          def handle_msg(self, msg):
              inMsg = pmt.to_python (msg)
              pld = inMsg[1]
              
              res = ""
              for i in pld:
          	    res = res + chr(i)
              
              print (str(res))
              #print (pld)
              #mLen = len(pld)
              # print (mLen)
              #if (mLen > 0):
              #    char_list = [85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,225,90,232,147]
              #    char_list.append (mLen >> 8)
              #    char_list.append (mLen & 255)
              #    char_list.append (mLen >> 8)
              #    char_list.append (mLen & 255)
              #    char_list.extend (pld)
                  # print (char_list)
              #    out_len = len(char_list)
                  # print (out_len)
                  #self.message_port_pub(pmt.intern('PDU_out'), pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(out_len,(char_list))))
  states: {}
- name: fft_bin
  id: blocks_probe_signal_x
  parameters:
    type: int
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_length
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_length)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '1000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(freq)
    gain1: '''fast_attack'''
    manual_gain1: '60'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: import_1
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (symb_rate/2)*(1+Ex_BW)
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: burst
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_2
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,1,1,1
    name: '"Constellation after Costas Loop"'
    size: '1024'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_const_sink_x_0_2_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,0,1,1
    name: '"Constellation after Symbol Sync"'
    size: '1024'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_const_sink_x_0_2_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,1
    name: '"Constellation after AGC"'
    size: int(1024/2)
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/20
    fc: '0'
    fftsize: fft_length
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,1
    name: '"Received Spectrum"'
    type: complex
  states: {}
- name: qtgui_number_sink
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,0,2,2
    name: '"CFO Val"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    name: '"Decoded Data"'
    size: '128'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,1,1,1
    label1: Signal 1 - I
    label2: Signal 1 - Q
    name: '"Received signal after AGC"'
    size: '256'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,1,1,1
    name: '"Decoded Data"'
    size: '128'
    srate: samp_rate/4
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: sps
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq  + probe_fft_bin
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: to_cfo_calc
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: to_demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: to_cfo_calc
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: to_demod
  states: {}

connections:
- [analog_agc_xx_1, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_1, '0', qtgui_time_sink_x_1, '0']
- [analog_agc_xx_1, '0', rational_resampler_xxx_0, '0']
- [analog_agc_xx_1, '0', virtual_sink_0, '0']
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_int_to_float_0, '0', qtgui_number_sink, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', rational_resampler_xxx_1, '0']
- [blocks_nlog10_ff_0, '0', blocks_argmax_xx_0, '0']
- [blocks_repack_bits_bb_1_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_short_to_float_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_2, '0']
- [digital_costas_loop_cc_0_0, '0', virtual_sink_1, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_2_0, '0']
- [epy_block_0, '0', blocks_int_to_float_0, '0']
- [epy_block_0, '0', fft_bin, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', analog_agc_xx_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_1, PDU_in]
- [rational_resampler_xxx_0, '0', qtgui_const_sink_x_0_2_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_stream_to_vector_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_1, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
