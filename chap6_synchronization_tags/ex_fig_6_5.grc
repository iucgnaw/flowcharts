options:
  parameters:
    generate_options: qt_gui
    id: ex_fig_6_5
    output_language: python
    title: Figure 6.5 NRF24L01+ transmitter
  states: {}

blocks:
- name: ch
  id: variable
  parameters:
    value: '120'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2400e6+ch*1e6
  states: {}
- name: payload
  id: variable
  parameters:
    value: '"24.25"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (symbol_rate/2)
    gain: '1.0'
    samp_rate: samp_rate
    width: 250e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("trig")
    period: '2000'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: int(samp_rate/symbol_rate)
    sensitivity: 1.5707/(samp_rate/symbol_rate)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '16'
    bandwidth: '2000000'
    buffer_size: '0x200'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq)+int(12e3)
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: nordic_nordic_tx_0
  id: nordic_nordic_tx
  parameters:
    channel_count: '1'
  states: {}
- name: nordic_nordictap_transmitter_0
  id: nordic_nordictap_transmitter
  parameters:
    address: '''\xE7\xE7\xE7\xE7\xE7'''
    channel_count: ch
    channel_index: '0'
    payload: payload
    sequence_number: '0'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: int(freq)+int(12e3)
    gain0: '16'
    if_gain0: '20'
    sample_rate: int(samp_rate)
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pfb_synthesizer_ccf_0
  id: pfb_synthesizer_ccf
  parameters:
    ch_map: '[]'
    connections: '1'
    numchans: '1'
    taps: taps
    twox: 'False'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.2'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"squelch_sob"'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TX
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_message_strobe_0, strobe, nordic_nordictap_transmitter_0, trig]
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_mod_0, '0', pfb_synthesizer_ccf_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_1, '0']
- [nordic_nordic_tx_0, '0', virtual_sink_0, '0']
- [nordic_nordictap_transmitter_0, nordictap_out, nordic_nordic_tx_0, nordictap_in]
- [pfb_synthesizer_ccf_0, '0', iio_pluto_sink_0, '0']
- [pfb_synthesizer_ccf_0, '0', osmosdr_sink_0, '0']
- [virtual_source_0, '0', blocks_repack_bits_bb_0, '0']
- [virtual_source_0, '0', digital_gfsk_mod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
