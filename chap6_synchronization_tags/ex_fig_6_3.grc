options:
  parameters:
    generate_options: qt_gui
    id: ex_fig_6_3
    output_language: python
    title: Figure 6.3 C++ block implementation of message passing demonstration
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: message_boolean_0
  id: message_boolean
  parameters: {}
  states: {}
- name: message_boolean_recv_0
  id: message_boolean_recv
  parameters: {}
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', message_boolean_0, '0']
- [message_boolean_0, boolean, blocks_message_debug_0, print]
- [message_boolean_0, boolean, message_boolean_recv_0, boolean]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
