options:
  parameters:
    generate_options: qt_gui
    id: ex_fig_5_8
    output_language: python
    title: Figure 5.8 GRC QPSK modulator
  states: {}

blocks:
- name: Ex_BW
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '0.2'
    step: '0.05'
    stop: '0.6'
    value: '0.35'
  states: {}
- name: deltaf
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '-75000'
    step: '100'
    stop: '75000'
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 850e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '0'
    step: '3'
    stop: '49'
    value: '17'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '8'
  states: {}
- name: rrc_taps_tr
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts/2.0, sps, 1.0,  Ex_BW, int(5*sps*nfilts))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*symb_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: qpsk_msg_rec_symb
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: digital.constellation_qpsk().bits_per_symbol()
    comment: digital.constellation_qpsk().bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: digital.constellation_qpsk().points()
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: digital.constellation_qpsk().points()
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: digital.constellation_qpsk().pre_diff_code()
    map: digital.constellation_qpsk().pre_diff_code()
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: gain
    bandwidth: '1000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq)+deltaf
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: int(freq)+deltaf
    gain0: gain
    if_gain0: '20'
    sample_rate: int(samp_rate)
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: firdes.root_raised_cosine(nfilts/2.0, sps, 1.0,  0.35, int(5*sps*nfilts))
    nfilts: nfilts
    rrate: sps
    taps: rrc_taps_tr
    type: ccf
  states: {}
- name: qtgui_eye_sink_x_1
  id: qtgui_eye_sink_x
  parameters:
    grid: 'True'
    label1: Signal 1 - I
    label2: Signal 1 - Q
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Signal 1 - I
    label2: Signal 1 - Q
    size: '256'
    srate: samp_rate
    type: complex
    ymax: '1.1'
    ymin: '-1.1'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_map_bb_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_map_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [pfb_arb_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [pfb_arb_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_eye_sink_x_1, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
