options:
  parameters:
    generate_options: qt_gui
    id: ex_fig_5_28
    output_language: python
    title: Figure 5.28 RDS decoding
  states: {}

blocks:
- name: my_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: rdsTaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 2.6e3
    gain: '1'
    samp_rate: 250e3
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: rrc_taps_rec
  id: variable
  parameters:
    value: firdes.root_raised_cosine(5.65, 8, 1.0,  1.0, 11*8)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '1e-1'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: France_Inter_250ksps
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: my_const
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*numpy.pi/2000
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: 1.0/numpy.sqrt(2.0)
    loop_bw: 2*numpy.pi/1000
    max_dev: '1.5'
    nfilters: '8'
    osps: '1'
    pfb_mf_taps: rrc_taps_rec
    resamp_type: digital.IR_PFB_MF
    sps: '8'
    ted_gain: '3'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '1'
    samp_rate: 250e3
    taps: rdsTaps
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: |-
      Output:
        19 kSa/s
    nfilts: '32'
    rrate: 19000/250e3
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,1,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,1
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,1
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,1
    label1: Signal 1 - I
    label2: Signal 1 - Q
    size: '256'
    srate: '19000'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters:
    comment: from gr-rds
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters:
    comment: from gr-rds
    gui_hint: 0,0,1,2
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    comment: from gr-rds
    pty_locale: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sync
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rdsSym
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sync
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: Extract RDS information.
    stream_id: rdsSym
  states: {}

connections:
- [analog_agc2_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [analog_agc2_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_throttle2_0, '0', analog_wfm_rcv_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [pfb_arb_resampler_xxx_0, '0', virtual_sink_0, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_1, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
