options:
  parameters:
    generate_options: qt_gui
    id: ex_fig_5_12
    output_language: python
    title: Figure 5.12 Carrier frequency offset estimation
  states: {}

blocks:
- name: fft_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 850e6
  states: {}
- name: probe_fft_bin
  id: variable_function_probe
  parameters:
    block_id: fft_bin
    function_name: level
    poll_rate: '5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: fft_length
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_length
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: squared
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: |-
      4th power collapses
      all energy in a carrier
      at 4x the freq. offset
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_length
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_length
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_len=1024.0, samp_rate=32000.0, previous_freq=0.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Carrier Offset Calculation',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.int32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fft_len = fft_len
              self.samp_rate = samp_rate
              self.previous_freq = previous_freq
              #self.my_log = gr.logger(self.alias())
                  
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              if (input_items[0][0] > self.fft_len/2):
                 freq = -(1-(input_items[0][0]/self.fft_len))*self.samp_rate
              else:
              	freq = (input_items[0][0]/self.fft_len)*self.samp_rate
              	
              #fr = freq[-1].astype(np.float) 
              #print('fr =', fr)
            	
              #pr_fr = self.previous_freq  
              #print('pr_fr =', pr_fr)    
              
              if (self.previous_freq == 0.0):
              	self.previous_freq = freq
              	#print(self.previous_freq)
              else:
              	#print('Calc = ', abs(self.previous_freq[-1].astype(np.float) - freq[-1].astype(np.float)))
              	#print('Freq = ', freq[-1].astype(np.float))
              	freq = self.previous_freq
              	#print('Previous_freq = ', self.previous_freq[-1].astype(np.float)) 
              	      	
              output_items[0][:] = np.round(freq).astype(int)
              return len(output_items[0])
    fft_len: fft_length
    previous_freq: '0.0'
    samp_rate: samp_rate/20
  states: {}
- name: fft_bin
  id: blocks_probe_signal_x
  parameters:
    type: int
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_length
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_length)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (symb_rate/2)*(1+0.4)
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate/10
    fc: '0'
    fftsize: fft_length
    type: complex
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"FFT Val"'
    type: float
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '20'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: cfo_calc
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: cfo_calc
  states: {}

connections:
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_int_to_float_0, '0', qtgui_number_sink_1, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', rational_resampler_xxx_1, '0']
- [blocks_nlog10_ff_0, '0', blocks_argmax_xx_0, '0']
- [blocks_short_to_float_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', blocks_int_to_float_0, '0']
- [epy_block_0, '0', fft_bin, '0']
- [fft_vxx_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_1, '0', blocks_stream_to_vector_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_2, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
