options:
  parameters:
    generate_options: qt_gui
    id: ex4_05
    output_language: python
    title: '4.2 ... Correlation for CDMA decoding: the case of GPS - 2'
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: 4096*4
  states: {}
- name: df
  id: variable_qtgui_range
  parameters:
    comment: |-
      Manual Doppler shift
      compensation
    start: '-15000'
    step: '100'
    stop: '15000'
    value: '-1300'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.023e6
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      GPS signal 
      record
    file: 3genuine_69dB_11h15_1.sigmf-data
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    comment: Gold code PRN9
    file: GPSL1CA_PRN09.sigmf-data
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    comment: Gold code PRN23
    file: GPSL1CA_PRN23.sigmf-data
    repeat: 'True'
    type: float
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_0_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_0_0_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: float
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_0_0_1_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: float
    window: window.blackmanharris(N)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: df
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"xcorr prn9"'
    size: N
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"xcorr prn 23"'
    size: N
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_1, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_file_source_1_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fft_vxx_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0, '0', fft_vxx_0_0_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_1, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_0_1_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [fft_vxx_0_0_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0_0_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [fft_vxx_0_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_0_1_0, '0', blocks_multiply_conjugate_cc_0_0_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
